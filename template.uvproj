# Keil uVision project template.uvproj, settings and files
target rt-thread (ARM-ADS)
  device: STM32F051R8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: template
  c flags: Optim=4 OneElfS=1
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
